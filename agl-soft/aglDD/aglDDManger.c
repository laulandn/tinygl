/*
** aglDDManager.c - Device Driver Manager routines , version: 0.9
*/

/*
** AGL driver for Mesa 3D Graphics Library.
** Version: 0.9
** Mesa version: 2.4
**
** Copyright(C) 1995-97 Miklos Fazekas
** E-Mail: boga@augusta.inf.elte.hu
** WWW: http://www.elte.hu/~boga/Mesa.html
** 
** Part of the Mesa 3D Graphics Library for MacOS.
**
*/
 
/*
** Copyright 1995-97, Mikl—s Fazekas.
** All Rights Reserved.
** 
** This library is free software; you can redistribute it and/or
** modify it under the terms of the GNU Library General Public
** License as published by the Free Software Foundation; either
** version 2 of the License, or (at your option) any later version.
**
** This library is distributed in the hope that it will be useful,
** but WITHOUT ANY WARRANTY; without even the implied warranty of
** MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the GNU
** Library General Public License for more details.
**
** You should have received a copy of the GNU Library General Public
** License along with this library; if not, write to the Free
** Software Foundation, Inc., 675 Mass Ave, Cambridge, MA 02139, USA.
*/

/*
 * 1997/09/04: Added gl_Viewport to DDInitializeContext
 *
 * 1997/06/22: Added error checking to DDregisterEngine.
 *
 * 1997/06/18: Added InstallRaveDriver to DDChoosePixFmt. And fixed a bug in DDChoosePixFmt
 *
 *
 * 1997/03/31: DDUpdateContext updated: if there is not enought memory for a larger buffer try
 *			   to reset the original.
 *
 * 1997/03/31: DDUpdateContext updated: sets Mesa's NoRaster flag when there is not enough
 *			   memory. And DDSwapBuffer.
 *			   New functions added: DDBeginMesaCritical, DDEndMesaCritical, DDIsInCritical.
 */

/* OpenGL */
#include <gl.h>
#include <agl.h>

/* AGL */
#include "aglConfig.h"

#include "aglMemUtil.h"
#include "aglError.h"

#include "aglContext.h"
#include "aglPixelFormat.h"
#include "aglDD.h"
#include "aglDDManager.h"

#include "aglDDUtil.h"


/* Mesa */
#include "types.h"
#include "context.h"

#include "matrix.h"

/******************************************************************************************
 *
 * Static variables used by this file's functions only.
 *
 ******************************************************************************************/
/* static const 	GLint		kMaxDrivers	 =	20;	*/	
#define 						kMaxDrivers		20	/* Maximum number of drivers */

static GLint		gNumOfDrivers = 0;			/* The Number of drivers installed */
static TDDDriverFT	gDriverTable[kMaxDrivers];	/* Driver Table, wich hold information about the driver */

/******************************************************************************************
 *
 * GetDriverID: Return the driver ID from the pixelformat. 
 * So the gDriverTable[GetDriverID(pix)-1] corresponds the driver.
 * 0 returned if this is an invalid pixel-format.
 *
 ******************************************************************************************/
static int GetDriverID(const AGLPixelFmt inPixFmt)
{
	if (!AGLIsValidPixelFormat(inPixFmt))
	{
		AGLSetAGLError(NULL,AGL_BAD_PIXELFMT,"GetDriverID: bad pixel format!");
		return 0;
	}
	
	if ((inPixFmt->driverID <= kMaxDrivers) && (inPixFmt->driverID >= 1))
	{
		return inPixFmt->driverID;
	}
	else
	{
		return 0;
	}
}

/******************************************************************************************
 *
 * GetDriverFT: Return the driver Function table from the pixel format.
 *
 ******************************************************************************************/
static TDDDriverFT*	GetDriverFT(const AGLPixelFmt inPixFmt)
{
	TDDDriverFT	*result;
	int driverNum;
	
	if (!AGLIsValidPixelFormat(inPixFmt)) 
	{
		return NULL; 
	}
	
	driverNum = GetDriverID(inPixFmt);
		
	result = &gDriverTable[driverNum-1];
	return result;
}

/******************************************************************************************
 *
 * GetDriverFT: Registers a new device driver.
 *
 ******************************************************************************************/
GLboolean DDRegisterDriver(const TDDDriverFT *inDriverFT)
{
	if (inDriverFT == NULL)
	{
		AGLFatalCStr("DDRegister driver: inDriverFT is NULL!");
		return GL_FALSE;
	}
	
	if (gNumOfDrivers < (kMaxDrivers-1))
	{
		gNumOfDrivers++;
		gDriverTable[gNumOfDrivers-1] = *inDriverFT;
		return GL_TRUE;
	}
	else
	{
		return GL_FALSE;
	}
}

/******************************************************************************************
 *
 * DDInitializeContext: Initializes the context.
 *
 ******************************************************************************************/
GLboolean DDInitializeContext(AGLContext aglCtx)
{
	GLboolean succes;
	
    /*
	 * Attach the Driver-FT to the context.
	 */
	aglCtx->driverFT = GetDriverFT(&aglCtx->pixelFormat);
	
	if (aglCtx->driverFT == NULL) 
	{
		AGLSetAGLError(NULL,AGL_BAD_PIXELFMT,"Bad pixel format given to DDInitializeContext");
		return GL_FALSE;
	}
	
	/*
	 * Initialize the context with the selected driver
	 */
	DDUClearDriverFuncs(aglCtx->gl_ctx);
	succes = (*aglCtx->driverFT->initializeContext)(aglCtx->gl_ctx,aglCtx,&aglCtx->pixelFormat,aglCtx->drawable);
	
	if (!succes) 
	{
		/* 
		 * If the initalization failed we shoud disable all rendering:
		 */
		DDUBeginErrorMode(aglCtx->gl_ctx);
		 
		return GL_FALSE;
	}
	else
	{
		gl_update_state(aglCtx->gl_ctx);
	}
	
	
	/* 
	 * Update the state of the context.
	 */
	
	(*aglCtx->driverFT->updateState)(aglCtx->gl_ctx);
	
	/*
	 * Set the current buffer to front buffer's
	 */
	succes = (*aglCtx->gl_ctx->Driver.SetBuffer)(aglCtx->gl_ctx,aglCtx->pixelFormat.doubleBuffer ? GL_BACK : GL_FRONT);
	
	if (!succes)
	{
		AGLSetGLError(aglCtx,AGL_ERROR,"DDInitialize context: SetBuffer failed!");
		return GL_FALSE;
	}
	
	/*
	 * Store the port width/height.
	 */
	aglCtx->width = (aglCtx->drawable->portRect).right-(aglCtx->drawable->portRect).left;
	aglCtx->height = (aglCtx->drawable->portRect).bottom-(aglCtx->drawable->portRect).top;
	
	/*
	 * Initialize viewport to window size.
	 */ 
	if (aglCtx->gl_ctx->Viewport.Width == 0)
	{
		gl_Viewport( aglCtx->gl_ctx, 0, 0, aglCtx->width ,aglCtx->height ); 
		/* gl_ResizeBuffersMESA( aglCtx->gl_ctx ); */
	}
	
	return GL_TRUE;
}
/******************************************************************************************
 *
 * DDDestroyContext: Destorys the context.
 *
 ******************************************************************************************/
GLboolean DDDestroyContext(AGLContext aglCtx )
{
	GLboolean succes = GL_TRUE;
	
	AGLAssert(AGLIsValidContext(aglCtx));
	AGLAssert(aglCtx->driverFT);
	
	succes = (*aglCtx->driverFT->destroyContext)(aglCtx->gl_ctx);
	
	aglCtx->driverFT = NULL;
	
	return succes;
}

/******************************************************************************************
 *
 * DDUpdateContext: Notify the driver that the drawable size/pos/depth has changed.
 *
 ******************************************************************************************/

GLboolean DDUpdateContext(AGLContext aglCtx )
{
	GLboolean succes = GL_TRUE;
	GLboolean moved,resized = GL_FALSE;
	GLboolean wasInCritical = GL_FALSE;
	GLboolean monitorChanged = GL_FALSE;
	Rect 	  rect;
	
	AGLAssert(aglCtx);
	AGLAssert(aglCtx->drawable);
	
	
	/*
	 * Is Mesa in critical state?
	 */
	wasInCritical = DDIsMesaInCritical(aglCtx);
	
	/* 
	 * Is the drawable was moved. 
	 */
	DDUGetPortGlobalRect(aglCtx->drawable,&rect);
	
	if (rect.top != aglCtx->top ||
		rect.left != aglCtx->left)
	{
		/*
		 * Save the new top/left values 
		 */
		aglCtx->top		= rect.top;
		aglCtx->left	= rect.left;
		
		moved = GL_TRUE;
	}
	
	/*
	 * Is the drawable size was changed 
	 */
	if ( (rect.bottom-rect.top) != aglCtx->height ||
		 (rect.right-rect.left) != aglCtx->width )
	{
		/*
		 * Save the new size values 
		 */
	 	aglCtx->width	= (rect.bottom-rect.top);
	 	aglCtx->height	= (rect.bottom-rect.top);
	  
	 	resized = GL_TRUE;
	}
	
	
	/*
	 * Has the monitor configuration changed?
	 */
	monitorChanged = GL_TRUE;
	
	/*
	 * Tell the driver whats happend
	 */
	succes = (aglCtx->driverFT->updateContext)(aglCtx->gl_ctx,moved,resized);
	
	/*
	 * Resize the GL/Mesa buffers
	 */
	if (succes)
	{
		gl_ResizeBuffersMESA(aglCtx->gl_ctx);
	}
	
	/*
	 * If there were any error's we shoud put mesa into sleep mode
	 */
	if (!succes)
	{
		DDBeginMesaCritical(aglCtx);
	}
	else
	{
		if (wasInCritical)
		{
			DDEndMesaCritical(aglCtx); /* Finally there is enough room for resize */
		}
	}
	
	return succes;
}



/*
 * Makes the back buffer visible
 */

GLboolean DDSwapBuffers(AGLContext aglCtx)
{
	GLboolean succes;
   
    if (DDIsMesaInCritical(aglCtx)) 
    {
    	return GL_FALSE;
    }
    
	succes = (*aglCtx->driverFT->swapBuffers)(aglCtx->gl_ctx);
   
	if (succes)
	{
		/*
		 * TODO, (?) Flush the drawable.
		 */
		glFlush();
		
		return GL_TRUE;
	}
	else
	{
   		return GL_FALSE;
	}
}

GLvisual *DDGetMesaVisual(const AGLPixelFmt inPixelFmt)
{	
	if ( AGLIsValidPixelFormat(inPixelFmt)) 
	{
		return DDUCreateMesaVisual(inPixelFmt);
	} 
	else 
	{
		AGLSetAGLError(NULL,AGL_BAD_PIXELFMT,"DDGetMesaVisual: Bad pixel format!");
		return NULL;
	}
}



/*
 * Some built-in DD installer routine.
 */
extern GLboolean InstallColorQDDriver();
extern GLboolean InstallColor32Driver();
extern GLboolean InstallRAVEDriver();

AGLPixelFmt DDChoosePixelFmt(const TAGLPixelFmtReq *inPixFmt)
{
	AGLPixelFmt maxPixFmt; 	/* The pixel format of the selected (best) pixel-format */
	TDDSpeed	maxSpeed;	/* The speed of the selected pixel-format */
	int			maxDriver;	/* The driver ID of the selected pixel-format */
	
	AGLPixelFmt pixFmt;		/* The current pixel-format */
	int			i;			/* The current driver ID */
	
	
	/*
	 * Install some built-in device driver.
	 */
	if (gNumOfDrivers == 0) 
	{
		InstallColor32Driver();
		/* InstallRAVEDriver(); */
		/* InstallColor16Driver(); */
	}
	
	maxSpeed = kUnavaible;
    maxDriver = -1;
    maxPixFmt = NULL;
    
	for (i = 0; i < gNumOfDrivers; i++) 
	{
		pixFmt = (*gDriverTable[i].chooseMode)(inPixFmt);
		if (pixFmt != NULL) 
		{
			if (maxSpeed < pixFmt->speed) 
			{
				/*
				 * This is the driver for this pixel-fmt (yet).
				 */
				if (maxPixFmt != NULL)
				{
					AGLDisposePixelFormat(maxPixFmt);
				}
				maxSpeed = pixFmt->speed;
				pixFmt->driverID = i+1;
				maxPixFmt = pixFmt;
				maxDriver = i;
			}
			else
			{
				/*
				 * This driver is slow for this pix-fmt
				 */
				AGLDisposePixelFormat(pixFmt);
			}
		}
	}
	
	if (maxPixFmt == NULL) {
		return NULL;
	} 
	else 
	{
		return maxPixFmt; 
	}
}

/******************************************************************************************
 *
 * DDBeginMesaCritical: If we run out of memory we call this function it puts mesa to 
 *						NoRaster mode, so less crash should occur.
 *
 ******************************************************************************************/
 void	DDBeginMesaCritical( AGLContext aglCtx )
 {
 	aglCtx->criticalFlag = GL_TRUE;
 	/*
 	 * Set Mesa to NoRaster mode
 	 */
 	aglCtx->gl_ctx->NoRaster = GL_TRUE;
 }
/******************************************************************************************
 *
 * DDIsInCritical: Returns GL_TRUE if mesa is in sleep mode.
 *
 ******************************************************************************************/
GLboolean	DDIsMesaInCritical( AGLContext aglCtx )
{
 	return aglCtx->criticalFlag;
}
/******************************************************************************************
 *
 * DDEndMesa: There is enough memory to wake up Mesa.
 *
 ******************************************************************************************/
void	DDEndMesaCritical( AGLContext aglCtx )
{
	/* TODO: More checking */
 	aglCtx->criticalFlag = GL_FALSE;
 	/*
 	 * Set Mesa to NoRaster mode
 	 */
 	aglCtx->gl_ctx->NoRaster = GL_FALSE;
}