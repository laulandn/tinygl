/*
 * Simple framebuffer library written by Miklos Fazekas © 1997/08/12. All rights reversed.
 *
 * Supported cases: Multiplie pixel-depths, multiplie monitors, monitor mirroring.
 */

#ifndef topLeft
#define topLeft(rect)	((Point*)(&rect))[0]
#define botRight(rect)  ((Point*)(&rect))[1]
#endif /* topLeft */

#define ASSERT(value)	{ if (!(value)) DebugStr("\p Assert failed!"); }


#include "FB.h"
#pragma enumsalwaysint off
#include "QuickDraw.h"
#include "Gestalt.h"
#include "Displays.h"
#pragma enumsalwaysint reset

#include <QDOffscreen.h>

static Boolean gForceOffscreen;
static Boolean gDMPresent;

TFBError FBInit(void)
{
	long result;
	OSErr error;
	
	gForceOffscreen = true;
	gDMPresent = false;
	
	if (error = Gestalt(gestaltAddressingModeAttr,&result))
		return kFBGestaltFailed;
		
	if (!(result & 1 << gestalt32BitAddressing))
		return kFBGestaltFailed;
		
	if (error = Gestalt(gestaltSystemVersion,&result))
		return kFBGestaltFailed;
		
	if ((UInt32)result < (UInt32)0x0700) /* We are running 7.0 or earlyer */
		return kFBGestaltFailed;
	
	gDMPresent = false;
		
	if (error = Gestalt(gestaltDisplayMgrAttr,&result))
	{
		if (result & 1 << gestaltDisplayMgrPresent)
		{
			gDMPresent = true;
			DMIsMirroringOn(&gForceOffscreen);
		}	
		else
		{
		  gForceOffscreen = false;
		}
	}
	else
	{
		gForceOffscreen = false;
	}
	
	return kFBNoError;
}


static Boolean GoodRgn(const CGrafPtr inPort, const RgnHandle inRgn)
{
	/* Quick and dirty test for vis/clip rgns */
	Rect portRect,rgnRect;
	
	portRect = inPort->portRect;
	
	if ((**inRgn).rgnSize != 10)
		return false;
		
	rgnRect = (**inRgn).rgnBBox;
	
	if (!(rgnRect.top <= portRect.top))
		return false;
		
	if (!(rgnRect.bottom >= portRect.bottom))
		return false;
		
	if (!(rgnRect.left <= portRect.left))
		return false;
		
	if (!(rgnRect.right >= portRect.right))
		return false;
		
	return true;
}


static Boolean IsOnscreenPixMap(const PixMapHandle portPixMap)
{
	return ((GetPixBaseAddr(portPixMap)) == GetPixBaseAddr((**GetMainDevice()).gdPMap));
}

static TFBPixelType GetPortPixelType(const CGrafPtr inPort)
{
	PixMapHandle portPixMap = GetGWorldPixMap(inPort);
	
	if (portPixMap == NULL)
	   return kFBPixel_Invalid;
	
	if (IsOnscreenPixMap(portPixMap))
	{
		GWorldPtr origPort;
		GDHandle origDev;
		
		GDHandle maxDev;
		Rect	portRect;
		
		GetGWorld(&origPort,&origDev);
		SetGWorld(inPort,NULL);
		
		portRect = inPort->portRect;
		LocalToGlobal(&topLeft(portRect));
		LocalToGlobal(&botRight(portRect));
		
		SetGWorld(origPort,origDev);
		
		maxDev = GetMaxDevice(&portRect);
		
		if (maxDev == NULL) /* The window was moved out of the screen/screens: */
		{
			maxDev = GetMainDevice();
		}
		
		ASSERT(maxDev);
		
		switch ((**(**maxDev).gdPMap).pixelSize) {
			case 32:
				return kFBPixel_ARGB32;
			case 16:
				return kFBPixel_ARGB16;
			case 8:
				return kFBPixel_Index8;
			case 4:
				return kFBPixel_Index4;
			case 2:
				return kFBPixel_Index2;
			case 1:
				return kFBPixel_BW;
			default:
				return kFBPixel_Invalid;
		}
	}
	else
	{
		/* Offscreen GWorld */
		switch ((**portPixMap).pixelSize) {
			case 32:
				return kFBPixel_ARGB32;
			case 16:
				return kFBPixel_ARGB16;
			case 8:
				return kFBPixel_Index8;
			case 4:
				return kFBPixel_Index4;
			case 2:
				return kFBPixel_Index2;
			case 1:
				return kFBPixel_BW;
			default:
				return kFBPixel_Invalid;
		}
	}
}

static TFBPixelType GetBestPixelType(const TFBPixelMask inPixelMask, const TFBPixelType drawablePixelType)
{
	if ((inPixelMask & drawablePixelType) != 0)
		return drawablePixelType;
		
	switch (drawablePixelType)
	{
		case kFBPixel_BW:
			if ((inPixelMask & kFBPixel_Index2) != 0)
				return kFBPixel_Index2;
				
		case kFBPixel_Index2:
			if ((inPixelMask & kFBPixel_Index4) != 0)
				return kFBPixel_Index4;
				
		case kFBPixel_Index4:
			if ((inPixelMask & kFBPixel_Index8) != 0)
				return kFBPixel_Index8;	
				
		case kFBPixel_Index8:
			if ((inPixelMask & kFBPixel_ARGB16) != 0)
				return kFBPixel_ARGB16;
				
		case kFBPixel_ARGB16:
			if ((inPixelMask & kFBPixel_ARGB32) != 0)
				return kFBPixel_ARGB32;

		case kFBPixel_ARGB32:
			if ((inPixelMask & kFBPixel_ARGB16) != 0)
				return kFBPixel_ARGB16;
				
			if ((inPixelMask & kFBPixel_Index8) != 0)
				return kFBPixel_Index8;
				
			if ((inPixelMask & kFBPixel_Index4) != 0)
				return kFBPixel_Index4;
				
			if ((inPixelMask & kFBPixel_Index2) != 0)
				return kFBPixel_Index2;
				
			if ((inPixelMask & kFBPixel_BW) != 0)
				return kFBPixel_BW;
			
		default:
			return kFBPixel_Invalid;
	}
}

Boolean DirectWriteIsOK(const CGrafPtr inPort,const TFBPixelType inPixelType )
{
	PixMapHandle portPixMap;
	
	if (gForceOffscreen)
		return false;
		
	if (gDMPresent)
	{
		Boolean mirroring;
		DMIsMirroringOn(&mirroring);
		if (mirroring)
			return false;
	}
	
	
	portPixMap = GetGWorldPixMap(inPort);
	
	switch (inPixelType) {
		case kFBPixel_ARGB32:
		case kFBPixel_ARGB16:
			if ((**portPixMap).packType != 0)
				return false;
				
			if ((**portPixMap).packSize != 0)
				return false;
					
			if ((**portPixMap).pixelType != RGBDirect)
				return false;
			if (inPixelType == kFBPixel_ARGB32)
			{		
				if ((**portPixMap).pixelSize != 32)
					return false;
					
				if ((**portPixMap).cmpCount != 3)
					return false;
					
				if ((**portPixMap).cmpSize != 8)
					return false;
			}
			else /* inPixelType == kFBPixel_ARGB16 */
			{
				if ((**portPixMap).pixelSize != 16)
					return false;
					
				if ((**portPixMap).cmpCount != 3)
					return false;
					
				if ((**portPixMap).cmpSize != 5)
					return false;
			}	
			break;
		default:
			return false;
			break;
	}
	
	/* Rgn tests */
	if (!GoodRgn(inPort,inPort->visRgn))
		return false;
		
	if (!GoodRgn(inPort,inPort->clipRgn))
		return false;
		
	/* If this is an onscreen GrafPort */
	if (IsOnscreenPixMap(portPixMap))
	{
		GDHandle 	maxDev;
		GWorldPtr 	origPort;
		GDHandle 	origDev;
		Rect	portRect;
		
		GetGWorld(&origPort,&origDev);
		SetGWorld(inPort,NULL);
		
		portRect = inPort->portRect;
		LocalToGlobal(&topLeft(portRect));
		LocalToGlobal(&botRight(portRect));
		
		maxDev = GetMaxDevice(&portRect);
		
		SetGWorld(origPort,origDev);
		
		if (!PtInRect(topLeft(portRect),&(**maxDev).gdRect) || !PtInRect(botRight(portRect),&(**maxDev).gdRect))	
		{
			/* The window is not fully contained by the max gdevice */
			return false;
		}
	}
		
	return true;
}

void ZeroBuffer(TFBBuffer	*ioBuffer)
{
	ioBuffer->width = 0;
	ioBuffer->height = 0;
	ioBuffer->baseAddr = NULL;
	ioBuffer->botLeftAddr = NULL;
	ioBuffer->rowBytes;
	ioBuffer->port = NULL;
	
	ioBuffer->frontBuffer = NULL;
	ioBuffer->backBuffer = NULL;
	
	ioBuffer->drawable = NULL;
	
	ioBuffer->pixelType = kFBPixel_Invalid;
	ioBuffer->doubleBuffer = false;
}

int PixelTypeToDepth(const TFBPixelType inPixelType)
{
	return inPixelType;	
}

TFBError FBCreateBuffer(TFBBuffer 			*ioBuffer,
						const CGrafPtr 		inDrawable,
						const Boolean	 	inDoubleBuffer,
						const TFBPixelType 	inPixelMask)
{
	GWorldPtr	oldPort;
	GDHandle	oldDev;
	
	Rect 			drawableRect;
	int				width,height;
	TFBPixelType 	pixelType;
	
	if ((ioBuffer == NULL) || (inDrawable == NULL) || (inPixelMask == 0))
		return kFBParamError;
		
	/* Init the fields of the framebuffer */
	ZeroBuffer(ioBuffer);
	
	pixelType = GetPortPixelType(inDrawable);
	if (pixelType == kFBPixel_Invalid)
		return kFBBadDrawable;
	
	/* Get the dimension of the framebuffer */
	drawableRect = inDrawable->portRect;
	
	width  = drawableRect.right-drawableRect.left;
	height = drawableRect.bottom-drawableRect.top;
	
	/* Create the front buffer */
	ioBuffer->pixelMask = inPixelMask;
	ioBuffer->doubleBuffer = inDoubleBuffer;
	ioBuffer->drawable = inDrawable;
	

	if ((pixelType & inPixelMask) != 0)
	{
		if (DirectWriteIsOK(inDrawable,pixelType))
			ioBuffer->frontBuffer = inDrawable;
	}
	else
	{
		pixelType = GetBestPixelType(inPixelMask,pixelType);
	}
	
	if (pixelType == 0)
		return kFBParamError;
	
	if (!inDoubleBuffer)
	{
		ioBuffer->bufferMode = kFBBuffer_Front;
		
		if (ioBuffer->frontBuffer == NULL)
		{
			GWorldPtr oldPort;
			GDHandle oldDev;
			QDErr	 myErr;
		
			/* Create an offscreen front buffer */
			GetGWorld(&oldPort,&oldDev);
	
			SetGWorld(inDrawable,NULL);
			myErr = NewGWorld(	&ioBuffer->frontBuffer,PixelTypeToDepth(pixelType),
							&inDrawable->portRect,NULL,NULL,0);
							
			SetGWorld(oldPort,oldDev);					
		
			if (myErr || (ioBuffer->frontBuffer == NULL))
			{
				return kFBQDError;
			}
		}
	}
	
	
		
	if (inDoubleBuffer)
	{
		GWorldPtr 	oldPort;
		GDHandle	oldDev;
		QDErr		myErr;
		
		/* Create an offscreen back buffer */
		GetGWorld(&oldPort,&oldDev);
		
		SetGWorld(inDrawable,NULL);
		myErr = NewGWorld(	&ioBuffer->backBuffer,PixelTypeToDepth(pixelType),
							&inDrawable->portRect,NULL,NULL,0);
		
		SetGWorld(oldPort,oldDev);
		
		if (myErr || (ioBuffer->backBuffer == NULL))
		{
			return kFBQDError;
		}
		
		ioBuffer->bufferMode = kFBBuffer_Back;
	}
	
	ioBuffer->pixelType = pixelType;

	return kFBNoError;
}

void	FillBuffInfo( TFBBuffer *ioBuffer, GWorldPtr port)
{
	if (port == NULL)
	{
		ioBuffer->port = NULL;
		ioBuffer->width = 0;
		ioBuffer->height = 0;
		ioBuffer->rowBytes = 0;
		ioBuffer->baseAddr = 0;
		ioBuffer->botLeftAddr = 0;
	}
	else
	{
		Rect portRect;
		
		portRect = port->portRect;
		
		ioBuffer->port = port;
		ioBuffer->width = portRect.right-portRect.left;
		ioBuffer->height = portRect.bottom-portRect.top;
		
		ioBuffer->rowBytes = (**GetGWorldPixMap(port)).rowBytes & 0x3FFF;
		
		if (GetPixBaseAddr(GetGWorldPixMap(port)) ==  GetPixBaseAddr((**GetMainDevice()).gdPMap))
		{
			GWorldPtr origPort;
			GDHandle origDev;
			Point topLeft;
			Point botRight;
			Rect portRect;
			GDHandle device;
			
			device = GetMainDevice();
			

			
			/* Convert window boundries to global coordinates. */
			GetGWorld(&origPort,&origDev);
			SetGWorld(port,NULL);

			portRect = port->portRect;
			
			LocalToGlobal(&botRight(portRect));
			LocalToGlobal(&topLeft(portRect));
			SetGWorld(origPort,origDev);
			
			device = GetMaxDevice(&portRect);
			topLeft = topLeft(portRect);
			topLeft.v -= (**device).gdRect.top;
			topLeft.h -= (**device).gdRect.left;
			
			switch (ioBuffer->pixelType)
			{
				case kFBPixel_ARGB32:
					ioBuffer->baseAddr = (UInt8*)GetPixBaseAddr(GetGWorldPixMap(port))+(ioBuffer->rowBytes)*(topLeft.v)+(topLeft.h << 2);
					break;
				case kFBPixel_ARGB16:
					ioBuffer->baseAddr = (UInt8*)GetPixBaseAddr(GetGWorldPixMap(port))+(ioBuffer->rowBytes)*(topLeft.v)+(topLeft.h << 1);
					break;
				case kFBPixel_Index8:
					ioBuffer->baseAddr = (UInt8*)GetPixBaseAddr(GetGWorldPixMap(port))+(ioBuffer->rowBytes)*(topLeft.v)+(topLeft.h);
					break;
				default:
					DebugStr("\p Fatal Error!");
					break;
			}
		}
		else
		{
			/* Offscreen image: */
			ioBuffer->baseAddr = GetPixBaseAddr(GetGWorldPixMap(port));
		} 
		
		
		switch (ioBuffer->pixelType)
		{
			case (kFBPixel_ARGB32):
				ioBuffer->botLeftAddr = (UInt8*)ioBuffer->baseAddr+(ioBuffer->rowBytes)*(ioBuffer->height-1);
				break;
			case (kFBPixel_ARGB16):
				ioBuffer->botLeftAddr = (UInt8*)ioBuffer->baseAddr+(ioBuffer->rowBytes)*(ioBuffer->height-1);
				break;
			default:
				DebugStr("\p Fatal Error!");
				break;
		}
	}
}

TFBError FBLockBuffer(TFBBuffer	*ioBuffer)
{
	if (ioBuffer == NULL)
		 return kFBParamError;
		 
	if (ioBuffer->bufferMode == kFBBuffer_Front)
	{
		if (ioBuffer->frontBuffer == NULL)
		{
			FillBuffInfo(ioBuffer,NULL);
			return kFBParamError;
		}
		
		if (ioBuffer->frontBuffer != ioBuffer->drawable)
		{
			Boolean good;
			
			good = LockPixels(GetGWorldPixMap(ioBuffer->frontBuffer));
			if (!good)
			{
				FillBuffInfo(ioBuffer,NULL);
				return kFBQDError;
			}
		}
			
		FillBuffInfo(ioBuffer,ioBuffer->frontBuffer);
		return kFBNoError;
	}	
	else if (ioBuffer->bufferMode == kFBBuffer_Back)
	{
		Boolean good;
		
		if (ioBuffer->backBuffer == NULL)
		{
			FillBuffInfo(ioBuffer,NULL);
			return kFBParamError;
		}
		
		good = LockPixels(GetGWorldPixMap(ioBuffer->backBuffer));
		if (!good)
		{
			FillBuffInfo(ioBuffer,NULL);
			return kFBQDError;
		}
		
		FillBuffInfo(ioBuffer,ioBuffer->backBuffer);
		return kFBNoError;
	}
	else
	{
		return kFBParamError;
	}
}

TFBError FBUnlockBuffer(TFBBuffer *ioBuffer)
{
	if (ioBuffer == NULL)
		return kFBParamError;
		
	if (ioBuffer->port == NULL)
		return kFBNoError;	/* Already unlocked */
		
	if (ioBuffer->port != ioBuffer->drawable)
	{
		UnlockPixels(GetGWorldPixMap(ioBuffer->port));
	}
	
	FillBuffInfo(ioBuffer,NULL);
	return kFBNoError;
}

TFBError FBDisposeBuffer(TFBBuffer *ioBuffer)
{
	if (ioBuffer == NULL)
		return kFBParamError;
	
	if (ioBuffer->frontBuffer != ioBuffer->drawable && ioBuffer->frontBuffer != NULL)
	{
		DisposeGWorld(ioBuffer->frontBuffer);
	}
	
	if (ioBuffer->backBuffer != NULL)
	{
		DisposeGWorld(ioBuffer->backBuffer);
	}
	
	ZeroBuffer(ioBuffer);
	
	return kFBNoError;
}
void CopyPortBits(const GWorldPtr srcPort,GWorldPtr dstPort,const Boolean dithering)
{
	GWorldPtr 	origPort;	
	GDHandle	origDev;
	RGBColor	foreColor,backColor;
	RGBColor	whiteColor,blackColor;
		
	GetGWorld(&origPort,&origDev);
		
	SetGWorld(dstPort,NULL);
		
	GetForeColor(&foreColor); GetBackColor(&backColor);
		
	whiteColor.red = 0xFFFF; whiteColor.green = 0xFFFF; whiteColor.blue = 0xFFFF;
	blackColor.red = 0; blackColor.green = 0; blackColor.blue = 0;
	RGBForeColor(&blackColor);
	RGBBackColor(&whiteColor);
		
	CopyBits(	&((GrafPtr)srcPort)->portBits,		/* src */
				&((GrafPtr)dstPort)->portBits,			/* dst */
				&srcPort->portRect,&dstPort->portRect,	/* srcRect,dstRect */
				dithering ? srcCopy : ditherCopy,NULL);				/* mode,mask */
		
	RGBForeColor(&foreColor); RGBBackColor(&backColor);
	SetGWorld(origPort,origDev);
}

TFBError FBDisplayFrontBuffer(const TFBBuffer *ioBuffer, const Boolean dithering)
{
	if (ioBuffer == NULL)
		return kFBParamError;
		
	if (ioBuffer->frontBuffer != ioBuffer->drawable && ioBuffer->frontBuffer != NULL)
	{
		CopyPortBits(ioBuffer->frontBuffer,ioBuffer->drawable,dithering);
	}
}

TFBError FBSwapBuffers(TFBBuffer *ioBuffer, const Boolean dithering)
{
	if (ioBuffer == NULL)
		return kFBParamError;
		
	if (ioBuffer->backBuffer == NULL || !ioBuffer->doubleBuffer)
		return kFBParamError;
		
	if (ioBuffer->frontBuffer == NULL)
	{
		CopyPortBits(ioBuffer->backBuffer,ioBuffer->drawable,dithering);
	}
	else
	{
		/* Copy back buffer contents to the front buffer */
		CopyPortBits(ioBuffer->backBuffer,ioBuffer->frontBuffer,dithering);
		FBDisplayFrontBuffer(ioBuffer,dithering);
	}
}

Boolean FBIsBufferLocked(const TFBBuffer *inBuffer)
{
	return (inBuffer->rowBytes != 0);
}


TFBError FBUpdateBuffer( TFBBuffer *ioBuffer,
						  Boolean *outPixelTypeChanged)
{
	GWorldPtr	oldFrontBuffer;
	GWorldPtr	oldBackBuffer;
	PixelType	newPixelType;
	TFBError	error;
	
	if (!ioBuffer || !ioBuffer->drawable || !outPixelTypeChanged)
		return kFBParamError;
		
	if (FBIsBufferLocked(ioBuffer))
		return kFBParamError;

	newPixelType = GetPortPixelType(ioBuffer->drawable);
	
	ASSERT(newPixelType);
	
	oldFrontBuffer = ioBuffer->frontBuffer;
	oldBackBuffer = ioBuffer->backBuffer;
	
	ioBuffer->frontBuffer = NULL;
	ioBuffer->backBuffer = NULL;
	
	if (newPixelType & ioBuffer->pixelMask)
	{
		if (DirectWriteIsOK(ioBuffer->drawable,newPixelType))
		{
			ioBuffer->frontBuffer = ioBuffer->drawable;
			if ((oldFrontBuffer != ioBuffer->drawable) && (oldFrontBuffer != NULL))
			{
				DisposeGWorld(oldFrontBuffer);
				oldFrontBuffer = NULL;
			}
		}
	}
	else
	{
		newPixelType = GetBestPixelType(ioBuffer->pixelMask,newPixelType);
	}
	
	if ((ioBuffer->bufferMode == kFBBuffer_Front) && (ioBuffer->frontBuffer == NULL))
	{
		if ((oldFrontBuffer == ioBuffer->drawable) || (oldFrontBuffer == NULL))
		{
			GWorldPtr oldPort;
			GDHandle oldDev;
			QDErr	 myErr;
		
			/* Create an offscreen front buffer */
			GetGWorld(&oldPort,&oldDev);
	
			SetGWorld(ioBuffer->drawable,NULL);
			myErr = NewGWorld(	&ioBuffer->frontBuffer,PixelTypeToDepth(newPixelType),
							&ioBuffer->drawable->portRect,NULL,NULL,0);
							
			SetGWorld(oldPort,oldDev);					
		
			if (myErr || (ioBuffer->frontBuffer == NULL))
			{
				return kFBQDError;
			}
		}
		else
		{
			GWorldPtr 	oldPort;
			GDHandle	oldDev;
			GWorldFlags	flags;
			
			/* Update the ofscreen front buffer */
			GetGWorld(&oldPort,&oldDev);
			
			SetGWorld(ioBuffer->drawable,NULL);
			ioBuffer->frontBuffer = oldFrontBuffer;
			
			flags = UpdateGWorld(&ioBuffer->frontBuffer,PixelTypeToDepth(newPixelType),&ioBuffer->drawable->portRect,
								NULL,NULL,0);
			
			SetGWorld(oldPort,oldDev);
			if (flags & gwFlagErr)
			{		
				return kFBQDError;
			}
		}
	}
	else
	{
		if ((oldFrontBuffer != NULL) && (oldFrontBuffer != ioBuffer->drawable))
		{
			DisposeGWorld(oldFrontBuffer);
			oldFrontBuffer = NULL;
		}
	}
	
	if (ioBuffer->doubleBuffer)
	{
		if (oldBackBuffer == NULL)
		{
			GWorldPtr oldPort;
			GDHandle oldDev;
			QDErr	 myErr;
		
			/* Create an offscreen back buffer */
			GetGWorld(&oldPort,&oldDev);
	
			SetGWorld(ioBuffer->drawable,NULL);
			myErr = NewGWorld(	&ioBuffer->backBuffer,PixelTypeToDepth(newPixelType),
							&ioBuffer->drawable->portRect,NULL,NULL,0);
							
			SetGWorld(oldPort,oldDev);					
		
			if (myErr || (ioBuffer->frontBuffer == NULL))
			{
				return kFBQDError;
			}
		}
		else
		{
			GWorldPtr 	oldPort;
			GDHandle	oldDev;
			GWorldFlags	flags;
			
			/* Update the ofscreen back buffer */
			GetGWorld(&oldPort,&oldDev);
			
			SetGWorld(ioBuffer->drawable,NULL);
			ioBuffer->backBuffer = oldBackBuffer;
			
			
			{
				int depth = PixelTypeToDepth(newPixelType);
				Rect portRect = ioBuffer->drawable->portRect;
				
				flags = UpdateGWorld(&ioBuffer->backBuffer,depth,&portRect,
								NULL,NULL,0);
			}
			
			SetGWorld(oldPort,oldDev);
			if (flags & gwFlagErr)
			{
				return kFBQDError;
			}
		}
	}
	
	if (newPixelType != ioBuffer->pixelType)
	{
		ioBuffer->pixelType = newPixelType;
		*outPixelTypeChanged = true;
	}
	
	return kFBNoError;	
}

TFBError FBSetBufferMode( TFBBuffer *ioBuffer,
						  const TFBBufferMode inMode)
{
	Boolean locked;
	TFBError error;
	
	if (ioBuffer == NULL)
		return kFBParamError;
		
	
	locked = FBIsBufferLocked(ioBuffer);
	
	
		
	if (inMode == kFBBuffer_Front)
	{
		if (ioBuffer->frontBuffer == NULL)
		{
			/* TODO Allocate a front buffer here */
			return kFBInvalidBufferMode;
		}
		else
		{	
			if (locked)
			{
				if ((error = FBUnlockBuffer(ioBuffer)) != kFBNoError)
					return error;
			}
			
			ioBuffer->bufferMode = kFBBuffer_Front;
			
			if (locked)
			{
				if ((error = FBLockBuffer(ioBuffer)) != kFBNoError)
					return error;
			}
			
			return kFBNoError;
		}
	}
	else if (inMode == kFBBuffer_Back)
	{
		if (locked)
		{
			if ((error = FBUnlockBuffer(ioBuffer)) != kFBNoError)
				return error;
		}
	
		if (!ioBuffer->doubleBuffer)
			return kFBInvalidBufferMode;
			
		if (ioBuffer->backBuffer == NULL)
			return kFBOutOfMemory;
	
		ioBuffer->bufferMode = kFBBuffer_Back;
		
		if (locked)
		{
			if ((error = FBLockBuffer(ioBuffer)) != kFBNoError)
				return error;
		}
		
		return kFBNoError;
	}
	else
	{
		return kFBParamError;
	}
}