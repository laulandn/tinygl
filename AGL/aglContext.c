/*
** aglContext.h - AGLContext related functions , version: 0.9
*/

/*
** AGL driver for Mesa 3D Graphics Library.
** Version: 0.91
** Mesa version: 2.3
**
** Copyright(C) 1995-97 Miklos Fazekas
** E-Mail: boga@augusta.inf.elte.hu
** WWW: http://www.elte.hu/~boga/Mesa.html
** 
** Part of the Mesa 3D Graphics Library for MacOS.
**
*/
 
/*
** Copyright 1995-97, Mikl—s Fazekas.
** All Rights Reserved.
** 
** This library is free software; you can redistribute it and/or
** modify it under the terms of the GNU Library General Public
** License as published by the Free Software Foundation; either
** version 2 of the License, or (at your option) any later version.
**
** This library is distributed in the hope that it will be useful,
** but WITHOUT ANY WARRANTY; without even the implied warranty of
** MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the GNU
** Library General Public License for more details.
**
** You should have received a copy of the GNU Library General Public
** License along with this library; if not, write to the Free
** Software Foundation, Inc., 675 Mass Ave, Cambridge, MA 02139, USA.
*/

/*
 * 1997/06/22: Changed the names from agl to __agl (for debugging)
 *
 * 1997/06/20: Added blank aglSwapHint. 
 *
 * 1997/03/31: Variables explicitly initaliezed in AGLAllocateContext.
 */


 
/* OpenGL */
#include <gl.h>
#include <agl.h>


/* AGL */
#include "aglConfig.h"

#include "aglMemUtil.h"
#include "aglError.h"

#include "aglContext.h"

#include "aglPixelFormat.h"
#include "aglDD.h"

/* Mesa */
#include "types.h"
#include "context.h"

/******************************************************************************************
 *
 * Static variables used by this file's functions only.
 *
 ******************************************************************************************/
static GLint		gAGLOptions = AGL_NONE;  /* The current rendering options */
static AGLContext	gAGLContext = NULL;		 /* The current rendering context */


/******************************************************************************************
 *            AGL utility functions:
 ******************************************************************************************/
 
/*******************************************************************************************
 *
 * Utility functions for Allocating/Disposing/Validating AGL Context.
 * Note: these routines don't generate errors!
 * 
 ******************************************************************************************/
static AGLContext AGLAllocateContext(void)
{
	AGLContext aglCtx;
	
	/*
	 * Allocates and clears the aglCtx sructure to NULL.
	 */
	aglCtx = (AGLContext)AGLMemoryNewClear(sizeof(__AGLContextRec));
	
	aglCtx->gl_ctx = NULL;
	aglCtx->gl_framebuffer = NULL;
	aglCtx->gl_visual = NULL;
	
	aglCtx->drawable = NULL;
	aglCtx->top = -1;
	aglCtx->left = -1;
	aglCtx->width = -1;
	aglCtx->height = -1;
	
	aglCtx->criticalFlag = GL_FALSE;
	aglCtx->aglError = AGL_NONE;
	
	aglCtx->options = AGL_NONE;
	
	aglCtx->driverFT = NULL;
	
	return aglCtx;
}

static void AGLDisposeContext(AGLContext inCtx)
{
	GLboolean succes;

	if (inCtx == NULL)
	{
		return;
	}
	
	/*
	 * Destroy device driver stuff
	 */
	if (inCtx->driverFT != NULL)
	{
		succes = DDDestroyContext(inCtx);
		
		if (!succes)
		{
			AGLSetAGLError(NULL,(GLenum)AGL_BAD_CONTEXT,"AGLDisposeContext: driver can't dispose it's data!");
		}
	}
	
	
	/*
	 * Destroy Mesa related stuff's
	 */
	if (inCtx->gl_framebuffer != NULL)
	{
		gl_destroy_framebuffer( inCtx->gl_framebuffer );
	}
	if (inCtx->gl_ctx != NULL)
	{
		gl_destroy_context( inCtx->gl_ctx );
	}
	if (inCtx->gl_visual != NULL)
	{
		gl_destroy_visual( inCtx->gl_visual );
	}
	

	/*
	 * Destroy the whole context
	 */
	AGLMemoryDelete( (AGLPtr) inCtx );
}

/*******************************************************************************************
 *
 * AGLIsValidDrawable: Returns GL_TURE, if the inCtx is a valid context.			    
 *
 ******************************************************************************************/
GLboolean AGLIsValidContext(AGLContext inCtx)
{
	if (inCtx == NULL)
	{
		return GL_FALSE;
	}
	
	return GL_TRUE; /* TODO */
}

/*******************************************************************************************
 *
 * AGLIsValidDrawable: Returns GL_TURE, if the inDrawable is a  valid drawable. 
 *
 ******************************************************************************************/
static GLboolean AGLIsValidDrawable(AGLDrawable inDrawable)
{
	if (inDrawable == NULL)
	{
		return GL_FALSE;
	}
	
	return GL_TRUE; /* TODO */
}


/*******************************************************************************************
 *
 * AGLGetCurrentContext: Returns the current context.
 * TODO: Thread's support.
 *
 ******************************************************************************************/
 static AGLContext AGLGetCurrentContext( void )
 {
 	return gAGLContext;
 }

/*******************************************************************************************
 * agl-public routines:
 *******************************************************************************************/
/*******************************************************************************************
 *
 * aglCreateContext: Create a new AGL rendering context
 *
 ******************************************************************************************/ 
AGLContext __aglCreateContext(AGLPixelFmt pix,AGLContext shareList)
{
  AGLContext	aglCtx;
  GLboolean		succes;	
  
  /*
   * Allocate the aglCtx structure.
   */
   
  aglCtx = AGLAllocateContext();
  
  if (aglCtx == NULL)
  {
    AGLSetGLError(NULL,GL_OUT_OF_MEMORY,"aglCreateContext:Out of memory, context couldn't created!");
    return NULL;
  }
  
  /* 
   * Gets pixel format information.
   */
  
  if ( !AGLIsValidPixelFormat(pix) )
  {
	AGLSetAGLError(NULL,AGL_BAD_PIXELFMT,"aglCreateContext:Pix is not valid!");
  	AGLDisposeContext(aglCtx);
  	return NULL;
  }
  
  aglCtx->pixelFormat = *pix;
  
  /*
   * Create a Mesa Visual for the pixelformat.
   */
  
  aglCtx->gl_visual = DDGetMesaVisual(pix);
  
  if (aglCtx->gl_visual == NULL) 
  {
  	  AGLSetAGLError(NULL,AGL_GL_ERROR,"aglCreateContext:The Mesa visual was not initialized!");
  	  AGLDisposeContext(aglCtx);
  	  return NULL;
  }
  				 
  /*
   * Create a Mesa Context
   */
  aglCtx->gl_ctx = gl_create_context(	aglCtx->gl_visual,
  										shareList ? shareList->gl_ctx : NULL,
  										(void *) aglCtx );
  									
  if (aglCtx->gl_ctx == NULL) 
  {
	  AGLSetAGLError(NULL,AGL_GL_ERROR,"aglCreateContext:gl_ctx was not initialized!");
      AGLDisposeContext(aglCtx);
      return NULL;
  }
  
  /*
   * Create Mesa framebuffer
   */
   
  aglCtx->gl_framebuffer = gl_create_framebuffer( aglCtx->gl_visual );
  									
  if (aglCtx->gl_framebuffer == NULL) 
  {
      AGLSetAGLError(NULL,AGL_GL_ERROR,"aglCreateContext:The gl_framebuffer was not initialized!");
  	  AGLDisposeContext(aglCtx);
  	  return NULL;
  }

  /*
   * Initialize the error handler on this ctx.
   */
  succes = AGLInitError( aglCtx );
  
  if ( !succes )
  {
  	 AGLSetAGLError(NULL,AGL_ERROR,"aglCreateContext:Could'n initialize the error handler!");
  	 AGLDisposeContext(aglCtx);
  	 return NULL;
  }
  
  return aglCtx;
}

/*******************************************************************************************
 *
 * aglDestroyContext: Destroys an AGL context.
 *
 ******************************************************************************************/ 
GLboolean __aglDestroyContext( AGLContext ctx )
{
	/*
	 * Check if it is a valid agl Context
	 */
	if (AGLIsValidContext(ctx)) 
	{
		/*
		 * Dispose the context
		 */
		AGLDisposeContext(ctx);
  
  		return GL_TRUE;
  	}
  	else
  	{
    	AGLSetAGLError(NULL,AGL_BAD_CONTEXT,"aglDestroyContext:Invalid context: ctx!");
    	
    	return GL_FALSE;
  	}
}

/*******************************************************************************************
 *
 * aglMakeCurrent: Attach an AGL context to a drawable.
 *
 ******************************************************************************************/ 
GLboolean __aglMakeCurrent( AGLDrawable drawable, AGLContext ctx )
{	
	GLboolean succes;

	if ((drawable == AGL_NONE) && (ctx == NULL))
	{
		/*
		 * Detach
		 */
		/* succes = DDDetachContext(gAGLContext); */
		gl_make_current(NULL,NULL);
		gAGLContext = NULL;
		
		return GL_TRUE;
	}
	
	
  	if ( !AGLIsValidDrawable(drawable) )
  	{
  		AGLSetAGLError(NULL,AGL_BAD_DRAWABLE,"aglMakeCurrent: Invalid drawable!");
  		
  		return GL_FALSE;
  	}

  
  	if ( !AGLIsValidContext(ctx) )
  	{ 
    	AGLSetAGLError(NULL,AGL_BAD_CONTEXT,"aglMakeCurrent: Invalid context!");
    	
    	return GL_FALSE;
  	}
  	
	/* Case 1: this is the first agl_make_current so initialize the frame buffer */
	if (ctx != NULL && ctx->drawable == NULL)
	{
		
		AGLAssert(drawable);
		ctx->drawable = drawable;

	
		
		gl_make_current(ctx->gl_ctx,ctx->gl_framebuffer);
		
		/* Initialize the context */
		if (!DDInitializeContext(ctx))
		{
			return GL_FALSE;
		}
		
		gAGLContext = ctx;
		__aglUpdateCurrent();
		return GL_TRUE;
	}
  	else if (ctx != NULL && ctx->drawable == drawable)
  	{
  		gl_make_current(ctx->gl_ctx,ctx->gl_framebuffer);
  		gAGLContext = ctx;
  		__aglUpdateCurrent();
  		return GL_TRUE;
  	}
	else
	{
		AGLSetAGLError(NULL,AGL_BAD_DRAWABLE,"aglMakeCurrent: Invalid context!");
		return GL_FALSE;
	}
}  	 
/*******************************************************************************************
 *
 * AGLSetCurrentContext: Sets the current context.
 *
 ******************************************************************************************/
/* static GLboolean AGLSetCurrentContext( AGLContext inCtx )
{
	GLboolean succes;
	
	if (inCtx == NULL) 
	{
  	 	gAGLContext = NULL;
  	 	DDMakeCurrent(NULL);
     	return GL_TRUE;
  	} 
  	else 
  	{
    	if ( AGLIsValidContext(inCtx) ) 
    	{
      		gAGLContext = inCtx;
      		gl_make_current( inCtx->gl_ctx, inCtx->gl_framebuffer );
      		succes = DDInitializeContext( inCtx );
    		
    		return succes;
    	} 
    	else 
    	{
      		AGLSetAGLError(inCtx,AGL_BAD_CONTEXT,"AGLSetCurrentContext:The context inCtx is invalid!");
      		
      		return GL_FALSE;
    	} 
    }
	}
  	succes = AGLSetCurrentContext( ctx );
  	
  	return succes;
 } */

/*******************************************************************************************
 *
 * aglCopyContext: Copy state from one rendering context to another.			   
 *
 ******************************************************************************************/

GLboolean __aglCopyContext( AGLContext src, AGLContext dst, GLuint mask )
{
	/*
	 * Check if the contexts are valid.
	 */
	if (!AGLIsValidContext(src) || !AGLIsValidContext(src))
	{
		AGLSetAGLError(NULL,AGL_BAD_ATTRIBUTE,"aglCopyContext:Bad attribute!");
  	
		return GL_FALSE;
	}
  
	/*
	 * Check if the mask is valid
	 */
	if ( (mask && GL_ALL_ATTRIB_BITS) != mask)
	{
  		AGLSetAGLError(NULL,AGL_BAD_ATTRIBUTE,"aglCopyContext:Bad attribute!");
  		
  		return GL_FALSE;
	}
	
	/*
	 * Copy the context
	 */
	gl_copy_context(src->gl_ctx,dst->gl_ctx,mask);
	
	return GL_TRUE;
}

/*******************************************************************************************
 *
 * aglUpdateCurrent-Notify that the window has changed size or position.
 *
 ******************************************************************************************/ 
GLboolean __aglUpdateCurrent( void )
{
	AGLContext aglCtx;
	GLboolean succes;
	
	/*
	 * Get the current context.
	 */
	aglCtx = __aglGetCurrentContext();
   
	if (aglCtx) 
	{
		/*
		 * Update the context
		 */
		succes = DDUpdateContext(aglCtx);
		
		return succes;
	} 
	else 
	{
		AGLSetAGLError(NULL,AGL_BAD_CONTEXT,"aglUpdateCurrent:No context to update!");
		
		return GL_FALSE;
	}
}

/*******************************************************************************************
 *
 * aglGetCurrentContext: Return the current context.			   
 *
 ******************************************************************************************/


AGLContext __aglGetCurrentContext(void)
{
  return AGLGetCurrentContext();
}

/*******************************************************************************************
 *
 * aglGetCurrentDrawable: Return the current drawable
 *
 ******************************************************************************************/
AGLDrawable __aglGetCurrentDrawable(void)
{
	AGLContext aglCtx;
	
	/*
	 * Get the current context.
	 */
	aglCtx = __aglGetCurrentContext();
  
	if (aglCtx == NULL)
	{ 
		return AGL_NONE;
	}
	else
	{
		return aglCtx->drawable;
	}
}

/*******************************************************************************************
 * 
 * aglSetOptions: Set special AGL options
 * TODO: Options are not yet functional.
 *
 ******************************************************************************************/
GLboolean __aglSetOptions( int options )
{
	/*
	 * Check that it is a valid option 
	 */
	if (options <= AGL_CURSOR_BLANKING) 
  	{
  		/*
  		 * Set the options
  		 */
  		if (__aglGetCurrentContext() == NULL)
  		{
    		gAGLOptions = options;
    	}
    	else
    	{
    		__aglGetCurrentContext()->options = options;
    	}
    	
    	return GL_TRUE;
  	}
  	else
  	{
  		AGLSetAGLError(__aglGetCurrentContext(),AGL_INVALID_OPERATION,"aglSetOptions:Invalid option!");
    	
    	return GL_FALSE; 
  	} 
}

/*******************************************************************************************
 * 
 * aglSwapBuffers: Make back buffer visible
 *
 ******************************************************************************************/
GLboolean	__aglSwapBuffers( void )
{
	GLboolean	succes;
	AGLContext	aglCtx;
	
	/*
	 * Get the current context.
	 */
	aglCtx = __aglGetCurrentContext();
	
	if (aglCtx == NULL) 
	{
	  AGLSetAGLError(NULL,AGL_BAD_CONTEXT,"aglSwapBuffers: Invalid current context");
      return GL_FALSE;
	}
	
	/*
	 * Check if it's double buffered
	 */
	if (!aglCtx->pixelFormat.doubleBuffer)
	{
		glFlush();
		
		return GL_TRUE;
	}
	
	/*
	 * Swap the buffer.
	 */
	succes = DDSwapBuffers(aglCtx);
	
	return succes;
}
/*******************************************************************************************
 * 
 * aglSwapHint: ??
 *
 ******************************************************************************************/

GLboolean __aglSwapHint(int x, int y, int width, int height)
{
	/* 
	 * TODO 
	 */
	return GL_FALSE;
}


/*******************************************************************************************
 *
 * aglQueryVersion: Return the version numbers of the AGL extension
 *
 ******************************************************************************************/
GLboolean __aglQueryVersion( int *major, int *minor )
{
	if ((major != NULL) && (minor != NULL)) 
	{
		*major = 1;
    	*minor = 0;
    	return GL_TRUE;
	} 
	else
	{	
		return GL_FALSE;
	}
}