/*
** aglContext.h - AGLContext related functions , version: 0.9
*/

/*
** AGL driver for Mesa 3D Graphics Library.
** Version: 0.9
** Mesa version: 2.2
**
** Copyright(C) 1995-97 Miklos Fazekas
** E-Mail: boga@augusta.inf.elte.hu
** WWW: http://www.elte.hu/~boga/Mesa.html
** 
** Part of the Mesa 3D Graphics Library for MacOS.
**
*/
 
/*
** Copyright 1995-97, Mikl—s Fazekas.
** All Rights Reserved.
** 
** This library is free software; you can redistribute it and/or
** modify it under the terms of the GNU Library General Public
** License as published by the Free Software Foundation; either
** version 2 of the License, or (at your option) any later version.
**
** This library is distributed in the hope that it will be useful,
** but WITHOUT ANY WARRANTY; without even the implied warranty of
** MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the GNU
** Library General Public License for more details.
**
** You should have received a copy of the GNU Library General Public
** License along with this library; if not, write to the Free
** Software Foundation, Inc., 675 Mass Ave, Cambridge, MA 02139, USA.
*/

/*
 * 1997/08/14: Now makes use of gTempMem
 */

/* OpenGL */
#include <gl.h>
#include <agl.h>

/* System */
#include <memory.h>

/* ANSI */
#include <stdlib.h>

/* AGL */
#include "aglConfig.h"

#include "aglMemUtil.h"
#include "aglError.h"

#include "macros.h"

/*******************************************************************************************
 *
 * AGLMemoryNew allocate memory, NULL is returned, if it's failed.
 *
 ******************************************************************************************/
AGLPtr 	AGLMemoryNew(
 					int size )		/* Size in bytes */
{
	return (AGLPtr) NewPtr(size);
}

/*******************************************************************************************
 *
 * AGLMemoryNewClear disposes memory, error generated if it's failed.
 *
 ******************************************************************************************/
AGLPtr	AGLMemoryNewClear(
					int size )
{
	return (AGLPtr) NewPtrClear(size);
}

/*******************************************************************************************
 *
 * AGLMemoryDelete disposes memory, error generated if it's failed.
 *
 ******************************************************************************************/
void	AGLMemoryDelete(
					AGLPtr ptr )
{
	DisposePtr ( (char*) ptr );
}

/*******************************************************************************************
 *
 * Routines for allocating, and releasing used only by MESA!!!
 * If there is not enough memory it won't give back NULL, it will give back an addres of
 * a large (64 KB, or as set in "aglMemUtil.c" in kTempMemSize size variable), it's also generates 
 * a GL_OUT_OF_MEMORY error.
 *
 * For performace issuse we are using the ansi-lib version of malloc/free/calloc.
 * TODO: Maybe do a sample memory managment in this 64 kb.
 * 
 ******************************************************************************************/ 

#define kTempMemSize MAX_WIDTH*sizeof(double)

static char gTempMem[kTempMemSize];			/* 64 kb of preallocated space */
static GLboolean gTempMemUsed = GL_FALSE;


char* AGLAlloc(
						int size )				/* Size in bytes */
{
	char*	result;
	if (!gTempMemUsed && size < kTempMemSize)
	{
		result = gTempMem;
		gTempMemUsed = GL_TRUE;
	}
	else
	{
		result = (char *)malloc(size);
	}
	
	if (result != NULL)
	{
		return result;
	}
	else
	{
		if (size >= kTempMemSize)
		{
			AGLFatalCStr("AGLAlloc: We are going to corrupt the memory, :) !");
		}
		
		/* 
		 * Tell Mesa, that we've ran out of memory
		 */
		AGLSetGLError(NULL,GL_OUT_OF_MEMORY,"AGLAlloc: We've ran out of memory!");
		
		/*
		 * Give out the Temporary memory
		 */
		return gTempMem;
	}
}
						
void AGLFree( 
						char* ptr )			/* Data to dispose */
{
	if (ptr != gTempMem)
	{
		free(ptr);
	}
	else
	{
		gTempMemUsed = GL_FALSE;
		/*
		 * We can't dispose the Temporary mem.
		 */
	}
}
char* MAC_ALLOC(			int size )
{
	return AGLAlloc(size);
}
void MAC_FREE( 
						char* ptr )			/* Data to dispose */
{
	AGLFree(ptr);
}

/*******************************************************************************************
 *
 * AGLGetFakeMem: returns a pointer to the preallocated fake-mem.
 *
 *******************************************************************************************/
AGLPtr AGLGetFakeMem()
{
	return (AGLPtr)gTempMem;
}
/*******************************************************************************************
 *
 * AGLGetFakeMem: returns TRUE, if the pointer ptr is fake-mem.
 *
 *******************************************************************************************/
Boolean AGLIsFakeMem(AGLPtr ptr)
{
	return (ptr == gTempMem);
}


