/*
** aglDDUtil.c - Device Driver utility functions for AGL.
*/

/*
** AGL driver for Mesa 3D Graphics Library.
** Version: 0.92
** Mesa version: 2.3
**
** Copyright(C) 1996 Miklos Fazekas
** E-Mail: boga@augusta.inf.elte.hu
** WWW: http://www.elte.hu/~boga/Mesa.html
** 
** Part of the port of the Mesa 3D Graphics Library for MacOSª
**
*/
 
/*
** Copyright 1996, Mikl—s Fazekas.
** All Rights Reserved.
** 
** This library is free software; you can redistribute it and/or
** modify it under the terms of the GNU Library General Public
** License as published by the Free Software Foundation; either
** version 2 of the License, or (at your option) any later version.
**
** This library is distributed in the hope that it will be useful,
** but WITHOUT ANY WARRANTY; without even the implied warranty of
** MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the GNU
** Library General Public License for more details.
**
** You should have received a copy of the GNU Library General Public
** License along with this library; if not, write to the Free
** Software Foundation, Inc., 675 Mass Ave, Cambridge, MA 02139, USA.
*/

/*
 * 1997/08/13: Added topLeft/botRight macros.
 *
 * 1997/08/13: Added DDUBeginError/DDUEndError
 *
 * 1997/08/13: Buffering stuffs moved to FB.c + Many code removed
 *
 * 1997/06/01: Modyfied gl_create_visual for Mesa 2.3
 */

#ifndef topLeft
#define topLeft(rect)	((Point*)(&rect))[0]
#define botRight(rect)  ((Point*)(&rect))[1]
#endif /* topLeft */


#include <stdio.h>

/* OpenGL */
#include <gl.h>
#include <agl.h>

/* AGL */
#include "aglConfig.h"

#include "aglMemUtil.h"
#include "aglError.h"
#include "aglDDUtil.h"

#include "aglPixelFormat.h"

/* Mesa */
#include "types.h"
#include "context.h"
#include "dd.h"
#include "config.h"

/* MacOS */
#include <QDOffscreen.h>

/*
#pragma profile on
 */
GLvisual *DDUCreateMesaVisual(const AGLPixelFmt inPixFmt)
{
	GLvisual *result;
	
	/*
	 * Create Mesa visual
	 */
	result = gl_create_visual(	inPixFmt->rgba,
				 	inPixFmt->softwareAlpha,
					inPixFmt->doubleBuffer,
					inPixFmt->depthSize,
					inPixFmt->stencilSize,
					inPixFmt->accumBits,
					inPixFmt->bufferSize,
					inPixFmt->redScale,inPixFmt->greenScale,
					inPixFmt->blueScale,inPixFmt->alphaScale,
					inPixFmt->redSize,inPixFmt->greenSize,
					inPixFmt->blueSize,inPixFmt->alphaSize );
								
	return result;
}

/*
 * This set's up depth,accum,stencil,
 */
GLboolean DDUMesaSetupPixelFmt(AGLPixelFmt ioPixFmt)
{
	int accumBits = 0;
	GLvisual *visual;
   
	/*
	 * Set up depth buffer size:
	 */
	if ( ioPixFmt->depthSize >0 )
	{
		if (ioPixFmt->depthSize <= DEPTH_BITS)
		{
			ioPixFmt->depthSize = DEPTH_BITS;
		}
		else
		{
	fprintf(stderr,"DDUMesaSetupPixelFmt failed depthSize!\n"); fflush(stderr);
			return GL_FALSE;
		}
	}
	else 
	{
		ioPixFmt->depthSize = 0 ;
	}
   
   	/*
     * Set up accumulation buffer size
     */
    accumBits = 0; 
    
   	if ( ioPixFmt->accumRedSize > accumBits) 
   	{
   		accumBits = ioPixFmt->accumRedSize;
	}
	if ( ioPixFmt->accumGreenSize > accumBits) 
   	{
   		accumBits = ioPixFmt->accumGreenSize;
	}
	if ( ioPixFmt->accumBlueSize > accumBits) 
   	{
   		accumBits = ioPixFmt->accumBlueSize;
	}
	if ( ioPixFmt->accumAlphaSize > accumBits) 
   	{
   		accumBits = ioPixFmt->accumAlphaSize;
	}
	
	if (accumBits > 0)
	{
		if (accumBits <=  sizeof(GLaccum))
		{
			accumBits = sizeof(GLaccum);
			ioPixFmt->accumBlueSize = accumBits;
	    	ioPixFmt->accumGreenSize = accumBits;
	    	ioPixFmt->accumBlueSize = accumBits;
	    	ioPixFmt->accumAlphaSize = accumBits;
	    	ioPixFmt->accumBits = accumBits;
		}
		else
		{
	fprintf(stderr,"DDUMesaSetupPixelFmt failed accumBits!\n"); fflush(stderr);
			return GL_FALSE;
		}
	}
	else
	{
		ioPixFmt->accumBlueSize = 0;
		ioPixFmt->accumRedSize = 0;
		ioPixFmt->accumGreenSize = 0;
		ioPixFmt->accumAlphaSize = 0;
		ioPixFmt->accumBits = 0;
	}
	
	/*
	 * Stencil buffer:
	 */
	if (ioPixFmt->stencilSize > 0)
	{
		if (ioPixFmt->stencilSize <= sizeof(GLstencil))
		{
			ioPixFmt->stencilSize = sizeof(GLstencil);
		}
		else
		{
	fprintf(stderr,"DDUMesaSetupPixelFmt failed stencilSize!\n"); fflush(stderr);
			return GL_FALSE;
		}
	}
	else
	{
		ioPixFmt->stencilSize = 0;
	}
	
	/*
	 * See if we can allocate a visual for this pixel-format:
	 */
	visual = DDUCreateMesaVisual(ioPixFmt);
	
	if (visual != NULL)
	{
		gl_destroy_visual(visual);
		return GL_TRUE;
	}
	else
	{
	fprintf(stderr,"DDUMesaSetupPixelFmt failed DDUCreateMesaVisual!\n"); fflush(stderr);
		return GL_FALSE;
	}
	
}



/************************************************************************************************
 *
 * DDUGetGDeviceMaxMinDepth: return the maximum/minimum nubmer of bits in a device chain.
 *
 ************************************************************************************************/
void		DDUGetGDeviceMaxMinDepth(const GDHandle *devices,const int ndev,int *maxDepth, int *minDepth)
{
	AGLAssert(maxDepth != NULL);
	AGLAssert(minDepth != NULL);

	if (devices == NULL)
	{
		GDHandle 				myDevice;
		long					targetDepth;
		
		myDevice = GetGDevice();
		targetDepth = (*(*myDevice)->gdPMap)->pixelSize;
		
		*maxDepth = targetDepth;
		*minDepth = targetDepth;
	}
	else 
	{
		int			currentDev;
		long		targetDepth;
		GDHandle 	myDevice;
				
		myDevice = *devices;
		targetDepth = (*(*myDevice)->gdPMap)->pixelSize;
		
		*maxDepth = targetDepth;
		*minDepth = targetDepth;
		
		for (currentDev = 0; currentDev < ndev; currentDev++)
		{
			myDevice = devices[currentDev];
			targetDepth = (*(*myDevice)->gdPMap)->pixelSize;
			
			if (targetDepth < *minDepth)
			{
				*minDepth = targetDepth;
			}
			
			if (targetDepth > *maxDepth)
			{
				*maxDepth = targetDepth;
			}
		}
	}
}



/**********************************************************************
 * Return's the port rectangle in global coordiantes.
 **********************************************************************/
 
 void DDUGetPortGlobalRect(const CGrafPtr port,Rect *outRect)
 {
 	GDHandle origDev;
 	GWorldPtr origPort;
 	Rect portRect;
 	Point topLeft;
 	Point botRight;
 	
 	AGLAssert(port);
 	AGLAssert(outRect);
 	
 	GetGWorld(&origPort,&origDev);
 	SetGWorld(port,NULL);
 	
 	*outRect = port->portRect;
 	
 	LocalToGlobal(&topLeft(*outRect));
 	LocalToGlobal(&botRight(*outRect));
 	
	SetGWorld(origPort,origDev);
 }
/*
#pragma profile reset
*/

static void error_func(GLcontext *ctx)
{
	AGLFatalCStr("ErrorFuncCalled: Possibly we run out of memory, call glGetError/aglGetError!");
}

static GLboolean error_bool_func(GLcontext *ctx)
{
	AGLDebugPStr("\pErrorFuncCalled: Possibly we run out of memory, call glGetError/aglGetError!");
	return GL_FALSE;
}

static GLboolean errorIndexMask(GLcontext *ctx, GLuint mask)
{
	AGLDebugPStr("\pErrorFuncCalled: Possibly we run out of memory, call glGetError/aglGetError!");
	return GL_TRUE;	
}

static GLboolean errorColorMask(GLcontext *ctx, GLboolean rmask, GLboolean gmask,
                           						GLboolean bmask, GLboolean amask)
{
	AGLDebugPStr("\pErrorFuncCalled: Possibly we run out of memory, call glGetError/aglGetError!");
	return GL_TRUE;	
}
static GLboolean errorLogicOp(GLcontext *ctx,  GLenum op )
{
	AGLDebugPStr("\pErrorFuncCalled: Possibly we run out of memory, call glGetError/aglGetError!");
	return GL_TRUE;	
}
static GLboolean errorRenderVB(GLcontext *ctx, GLboolean allDone )
{
	AGLDebugPStr("\pErrorFuncCalled: Possibly we run out of memory, call glGetError/aglGetError!d");
	return GL_TRUE;	
}


static void errorGetBufferSize(GLcontext *ctx,
								GLuint *width,
								GLuint *height)
{
	AGLDebugPStr("\pErrorFuncCalled: Possibly we run out of memory, call glGetError/aglGetError!");
	*width = 1;
	*height = 1;
}

static void errorUpdateState( GLcontext *ctx )
{
	AGLAssert(ctx);
	
	ctx->Driver.RendererString = NULL;
	
	ctx->Driver.UpdateState = errorUpdateState;
	
	ctx->Driver.ClearIndex = (void*)error_func;
	ctx->Driver.ClearColor = (void*)error_func;
	ctx->Driver.Clear = (void*)error_func;
	ctx->Driver.Index = (void*)error_func;
	ctx->Driver.Color = (void*)error_func;
	ctx->Driver.SetBuffer = (void*)error_func;
	ctx->Driver.GetBufferSize = errorGetBufferSize;
	
	ctx->Driver.WriteColorSpan = (void*)error_func;
	ctx->Driver.WriteMonocolorSpan = (void*)error_func;
	ctx->Driver.WriteColorPixels =(void*) error_func;
	ctx->Driver.WriteMonocolorPixels = (void*)error_func;
	ctx->Driver.WriteIndexSpan = (void*)error_func;
	ctx->Driver.WriteMonoindexSpan = (void*)error_func;
	ctx->Driver.WriteIndexPixels = (void*) error_func;
	ctx->Driver.WriteMonoindexPixels = (void*)error_func;
	
	ctx->Driver.ReadIndexSpan = (void*)error_func;
	ctx->Driver.ReadColorSpan = (void*)error_func;
	ctx->Driver.ReadIndexPixels = (void*)error_func;
	ctx->Driver.ReadColorPixels = (void*)error_func;
	
	
	ctx->Driver.Finish = (void*)error_func;
	ctx->Driver.Flush = (void*)error_func;
	
	ctx->Driver.IndexMask = errorIndexMask;
	ctx->Driver.ColorMask = errorColorMask;
	ctx->Driver.LogicOp = errorLogicOp;
	
	ctx->Driver.Dither = (void*)error_func;
	ctx->Driver.Error = (void*)error_func;
	
	ctx->Driver.NearFar = (void*)error_func;
	
	ctx->Driver.AllocDepthBuffer = (void*)error_func;
	ctx->Driver.ClearDepthBuffer = (void*)error_func;
	
	ctx->Driver.ReadDepthSpanFloat = (void*)error_func;
	ctx->Driver.ReadDepthSpanInt = (void*)error_func;
	
	
	ctx->Driver.TriangleFunc = (void*)error_func;
	ctx->Driver.PointsFunc = (void*)error_func;
	ctx->Driver.LineFunc = (void*)error_func;
	ctx->Driver.QuadFunc = (void*)error_func;
	ctx->Driver.RectFunc = (void*)error_func;
	
	ctx->Driver.DrawPixels = (void*)error_func;
	ctx->Driver.Bitmap = (void*)error_func;
	
	ctx->Driver.Begin = (void*)error_func;
	ctx->Driver.End = (void*)error_func;
	
	ctx->Driver.RasterSetup = (void*)error_func;
	ctx->Driver.RenderVB = errorRenderVB;
	
	ctx->Driver.TexImage = (void*)error_func;
	ctx->Driver.TexParameter = (void*)error_func;
	ctx->Driver.BindTexture = (void*)error_func;
	ctx->Driver.DeleteTexture = (void*)error_func;
}

void DDUBeginErrorMode(GLcontext *ctx)
{
	AGLAssert(ctx);
	
	errorUpdateState(ctx);
}

void empty_func(GLcontext *ctx)
{
	AGLFatalCStr("Warning:Mesa error: this device driver doesn't implements all Modatory functions!");
}

static void emptyGetBufferSize(GLcontext *ctx,
								GLuint *width,
								GLuint *height)
{
	AGLFatalCStr("Warning:Mesa error: this device driver doesn't implements all Modatory functions!");
	*width = 1;
	*height = 1;
}


/******************************************************************************************
 *
 * DDUClearDriverFuncs: Clears all drivers (except madatory functions).
 *
 ******************************************************************************************/
void DDUClearDriverFuncs(GLcontext *ctx)
{
	/* Mondatory functions: */
	ctx->Driver.RendererString = NULL;
	
	ctx->Driver.UpdateState = (void*)empty_func;
	ctx->Driver.ClearIndex = (void*)empty_func;
	ctx->Driver.ClearColor = (void*)empty_func;
	ctx->Driver.Clear = (void*)empty_func;
	ctx->Driver.Index = (void*)empty_func;
	ctx->Driver.Color = (void*)empty_func;
	ctx->Driver.SetBuffer = (void*)empty_func;
	ctx->Driver.GetBufferSize = emptyGetBufferSize;
	
	ctx->Driver.WriteColorSpan = (void*)empty_func;
	ctx->Driver.WriteMonocolorSpan = (void*)empty_func;
	ctx->Driver.WriteColorPixels =(void*) empty_func;
	ctx->Driver.WriteMonocolorPixels = (void*)empty_func;
	ctx->Driver.WriteIndexSpan = (void*)empty_func;
	ctx->Driver.WriteMonoindexSpan = (void*)empty_func;
	ctx->Driver.WriteIndexPixels = (void*) empty_func;
	ctx->Driver.WriteMonoindexPixels = (void*)empty_func;
	
	ctx->Driver.ReadIndexSpan = (void*)empty_func;
	ctx->Driver.ReadColorSpan = (void*)empty_func;
	ctx->Driver.ReadIndexPixels = (void*)empty_func;
	ctx->Driver.ReadColorPixels = (void*)empty_func;
	
	ctx->Driver.Finish = NULL;
	ctx->Driver.Flush = NULL;
	
	ctx->Driver.IndexMask = NULL;
	ctx->Driver.ColorMask = NULL;
	ctx->Driver.LogicOp = NULL;
	
	ctx->Driver.Dither = NULL;
	ctx->Driver.Error = NULL;
	
	ctx->Driver.NearFar = NULL;
	/* 
	 *	TODO:
	 *	ctx->Driver.AllocDepthBuffer = NULL;
	 *	ctx->Driver.ClearDepthBuffer = NULL;
	 *
	 *	ctx->Driver.ReadDepthSpanFloat = NULL;
	 *	ctx->Driver.ReadDepthSpanInt = NULL;
	 */
	
	ctx->Driver.TriangleFunc = NULL;
	ctx->Driver.PointsFunc = NULL;
	ctx->Driver.LineFunc = NULL;
	ctx->Driver.QuadFunc = NULL;
	ctx->Driver.RectFunc = NULL;
	
	ctx->Driver.DrawPixels = NULL;
	ctx->Driver.Bitmap = NULL;
	
	ctx->Driver.Begin = NULL;
	ctx->Driver.End = NULL;
	
	ctx->Driver.RasterSetup = NULL;
	ctx->Driver.RenderVB = NULL;
	
	ctx->Driver.TexImage = NULL;
	ctx->Driver.TexParameter = NULL;
	ctx->Driver.BindTexture = NULL;
	ctx->Driver.DeleteTexture = NULL;

}


void DDUEndErrorMode(GLcontext *ctx)
{
	AGLAssert(ctx);
	/* Remove masked functions: */
	DDUClearDriverFuncs(ctx);
}