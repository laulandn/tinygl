/*
** aglError.h - Error-handling related functions , version: 0.9
*/

/*
** AGL driver for Mesa 3D Graphics Library.
** Version: 0.9
** Mesa version: 2.2
**
** Copyright(C) 1995-97 Miklos Fazekas
** E-Mail: boga@augusta.inf.elte.hu
** WWW: http://www.elte.hu/~boga/Mesa.html
** 
** Part of the Mesa 3D Graphics Library for MacOS.
**
*/
 
/*
** Copyright 1995-97, Mikl—s Fazekas.
** All Rights Reserved.
** 
** This library is free software; you can redistribute it and/or
** modify it under the terms of the GNU Library General Public
** License as published by the Free Software Foundation; either
** version 2 of the License, or (at your option) any later version.
**
** This library is distributed in the hope that it will be useful,
** but WITHOUT ANY WARRANTY; without even the implied warranty of
** MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the GNU
** Library General Public License for more details.
**
** You should have received a copy of the GNU Library General Public
** License along with this library; if not, write to the Free
** Software Foundation, Inc., 675 Mass Ave, Cambridge, MA 02139, USA.
*/

/*
 * 1997/06/22 Added Notification error display to AGLFatalError
 *
 * 1997/03/31 Removed printf from AGLFatalError.
 */

/* OpenGL */
#include <gl.h>
#include <agl.h>

/* AGL */
#include "aglConfig.h"
#include "aglError.h"
#include "aglContext.h"

/* Mesa */
#include "context.h"
#include "types.h"

/* System */
#include <string.h>

#include <Notification.h>


/*
 * Debugger calls
 */
#ifdef __POWERPC__

#define BreakToLowLevelDebugger_()     SysBreak()
#define BreakStrToLowLevelDebugger_(s) SysBreakStr(s)
#define BreakToSourceDebugger_()       Debugger()
#define BreakStrToSourceDebugger_(s)   DebugStr(s)

#else /* 68K */

#define BreakToLowLevelDebugger_()     Debugger()
#define BreakStrToLowLevelDebugger_(s) DebugStr(s)
#define BreakToSourceDebugger_()       SysBreak()
#define BreakStrToSourceDebugger_(s)   SysBreakStr(s)

#endif

/******************************************************************************************
 *
 * Static variables used by this file's functions only.
 *
 ******************************************************************************************/
 /*
  * Global AGL error, used if there is no AGL-context.
  */
 static GLenum gAGLError = AGL_NO_ERROR; 
 
/******************************************************************************************
 *
 * Displays an error msg to the debugger.
 *
 ******************************************************************************************/
void AGL_assertion_failed(char *condition,char * filename,int lineno)
{
	int strend;
	char ErrorStr[255];
	
	ErrorStr[1] = 'A'; ErrorStr[2] = 's'; ErrorStr[3] = 's'; 
	ErrorStr[4] = 'e'; ErrorStr[5] = 'r'; ErrorStr[6] = 't';
	strcpy(&ErrorStr[7],condition);

	strcpy(&ErrorStr[strlen(&ErrorStr[1])+1],filename);
	/* strcpy(&ErrorStr[strlen(&ErrorStr[1])+1],lineno); */
	ErrorStr[0] = strlen(&ErrorStr[1]);
	BreakStrToSourceDebugger_ ( (ConstStr255Param) ErrorStr);
} 
 
 
static void AGLDisplayDebugStr(const char *message)
{
	char	ErrorStr[255];
		
	strcpy (&ErrorStr[1], message);
	ErrorStr[0] = strlen (message);
	BreakStrToSourceDebugger_ ( (ConstStr255Param) ErrorStr);
}

void AGLShowUserError(char *error)
{
	/* TODO : Caution Alert! */
}


/******************************************************************************************
 *
 * Initializes the context's error-status.
 *
 ******************************************************************************************/
GLboolean AGLInitError( AGLContext aglCtx )
{
	if (! AGLIsValidContext(aglCtx))
	{
		AGLFatalCStr("AGLInitError: aglCtx is invalid!");
		return GL_FALSE;
	}
	
	aglCtx->aglError = AGL_NO_ERROR;
	
	return GL_TRUE;
}

/******************************************************************************************
 *
 * AGLSetAGLError:Registers an agl-error, and displays the message, if AGL_DEBUG is on.
 *
 ******************************************************************************************/
void AGLSetAGLError( AGLContext aglCtx, GLenum error, const char *msg )
{
	if (aglCtx != NULL)
	{
		if (gAGLError == AGL_NO_ERROR && aglCtx->aglError == AGL_NO_ERROR)
		{
			aglCtx->aglError = error;
		}
	}
	else
	{
		if (gAGLError == AGL_NO_ERROR)
		{
			gAGLError = error; 
		}
	}
	
	#ifdef AGL_DEBUG
		AGLDisplayDebugStr(msg);
	#endif
}
/*
 * This is mesa's error registering routine
 */
extern void gl_error( GLcontext *ctx, GLenum error, const char *msg );
/******************************************************************************************
 *
 * AGLSetGLError:Registers a gl-error, and displays the message, if AGL_DEBUG is on, also
 * calls registers a AGL_GL_ERROR error.
 *
 ******************************************************************************************/
void AGLSetGLError( AGLContext aglCtx, GLenum error, const char *msg )
{
	/*
	 * Set the Mesa/GL error status
	 */
	if ( AGLIsValidContext(aglCtx) && (aglCtx->gl_ctx != NULL))
	{
		gl_error(aglCtx->gl_ctx,error,msg);
		
	}
	else
	{
		AGLContext ctx;
		/*
		 * Try to register this error to the current context.
		 */
		ctx = aglGetCurrentContext();
		
		if ( AGLIsValidContext(ctx) && ctx->gl_ctx != NULL )
		{
			gl_error(ctx->gl_ctx,error,msg);
		}
	}
}

/*******************************************************************************************
 *
 * aglGetError: Return the current error, in order: context-agl-error,context-gl-error,
 * global-agl-error. 
 *
 * "When an AGL error occurs, it remains flagged until aglGetError is called to 
 *  reset it. Additional errors occurring while an AGL error is still flagged are lost. 
 *  In other words, aglGetError returns the oldest error rather than the most 
 *  recent. This is useful behavior because the oldest error is often the cause of 
 *  subsequent errors."
 *
 ******************************************************************************************/
GLenum __aglGetError( void )
{
	GLenum result;
	AGLContext aglCtx;
	
	aglCtx = __aglGetCurrentContext();
   
	if (aglCtx != NULL)
	{
		/*
		 * First return the context's error, if there is one.
		 */
		if (aglCtx->aglError != AGL_NO_ERROR)
		{
			result = aglCtx->aglError;
			aglCtx->aglError = AGL_NO_ERROR;
		}
		/*
		 * Return the gl(Mesa) error
		 */
		else if (aglCtx->gl_ctx != NULL && aglCtx->gl_ctx->ErrorValue != GL_NO_ERROR)
		{
			result = AGL_GL_ERROR;
		}
		/*
		 * Return the global error, if there is one.
		 */
		else if (gAGLError != AGL_NO_ERROR)
		{
			result = gAGLError;
			gAGLError = AGL_NO_ERROR;
		}
		else
		{
			result = AGL_NO_ERROR;
		}
	}
	else
	{
		/*
		 * There is no current context, so return the global error.
		 */
		if (gAGLError != AGL_NO_ERROR)
		{
			result = gAGLError;
			gAGLError = AGL_NO_ERROR;
		}
		else
		{
			result = AGL_NO_ERROR;
		}
	}
	
	return result;
}